# Downgrade to match protobuf 4.25.3
PV = "4.25.3"
SRC_URI[sha256sum] = "25b5d0b42fd000320bd7830b349e3b696435f3b329810427a6bcce6a5492cc5c"
