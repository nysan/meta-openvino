# Downgrade to 4.25.3 on request (not intended for upstream)
PV = "4.25.3"
SRCREV = "4a2aef570deb2bfb8927426558701e8bfc26f2a4"

# CVE-2024-7254 fix is NOT present in 4.25.3
